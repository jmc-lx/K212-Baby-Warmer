# Keil uVision project BYD_MCU07A_BF7613BMXX_XXXX_V1.1.2.uvproj, settings and files
target BYD_MCU07A (MCS-51)
  device: BF7613BM28-SJLX BF7613BMXX-XXXX
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x7FFF) CLOCK(12000000)
  output: BYD_BF7613BMXXX_XXXX_V1_1_2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Inc;.\User
  link misc: REMOVEUNUSED
  group STARTUP
    ./: STARTUP.A51
  group User
    ./User/: main.c Project.c Touch_MCU_Init.c
    ./: dsp.c key.c buz.c fun.c ad.c
  group Source
    ./Source/: BF7613BMXX_XXXX_API_TK.c BF7613BMXX_XXXX_TraceMode.c BF7613BMXX_XXXX_API_Timer.c BF7613BMXX_XXXX_API_LVDT.c BF7613BMXX_XXXX_API_ADC.c
  group Library
    ./Lib/: BF7613BMXX_XXXX_CS_DataDeal_V1_0_0.LIB
  group ReadMe
    ./Doc/: ReadMe_UpdateLog.txt BF7613BMXX_XXXX_CS_DataDeal_V1_0_X_Updatelog.txt
